# Keil uVision project ROS.uvprojx, settings and files
target ROS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: X-CTRL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\Core\STM32F4xx_StdPeriph_Driver\inc;..\Core\CMSIS\Device\ST\STM32F4xx\Include;..\X-CTRL;..\Libraries\FreeRTOS;..\Libraries\FreeRTOS\Source\include;..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Libraries\AccelStepper-1.57\AccelStepper;..\Libraries\Rosserial_Arduino_Library\src\moveo_moveit;..\Libraries\Servo;..\Libraries\Rosserial_Arduino_Library\src;..\Driver;..\Libraries\Encoder;..\Libraries\elapsedMillis;..\USER;..\Libraries\ODriveArduino;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: main.cpp config.h CommonMacro.h
  group Libraries
    ../Libraries/AccelStepper-1.57/AccelStepper/: AccelStepper.cpp MultiStepper.cpp
    ../Libraries/Servo/: Servo.cpp
    ../Libraries/Rosserial_Arduino_Library/src/: duration.cpp time.cpp
    ../Libraries/ODriveArduino/: ODriveArduino.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp WString.cpp Stream.cpp WMath.cpp HardwareSerial.cpp WireBase.cpp Wire.cpp SPI.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group Driver
    ../Driver/: battery.cpp encoder.c PID.cpp motor.cpp Kinematics.cpp gy85.cpp MPU6050.cpp I2Cdev.cpp Imu.h imu_config.h
  group STM32F4xx_StdPeriph_Driver
    ../Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Core/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group CMSIS
    ../Core/: system_stm32f4xx.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
